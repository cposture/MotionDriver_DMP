# Keil uVision project MD移植.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MD移植 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_HD
  c include: ..\user;..\library\CMSIS;..\library\inc;..\user\I2C;..\user\MotionDriver;..\user\clock;..\user\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c stm32f10x_it.c
    ../user/MotionDriver/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../user/I2C/: i2c.c
    ../user/clock/: clock.c
    ../user/USART/: USART.c
  group doc
    ../doc/: 新建文本文档.txt
  group FWLIB
    ../library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../library/CMSIS/: core_cm3.c system_stm32f10x.c
  group startup
    ../library/CMSIS/startup/: startup_stm32f10x_hd.s
